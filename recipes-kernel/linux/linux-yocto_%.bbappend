FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
# Additional config fragments
SRC_URI += "file://enable-veth.cfg"
